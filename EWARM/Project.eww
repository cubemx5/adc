<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\adc4567.ewp</path>
  </project>
  <batchBuild />
</workspace>
